# Keil uVision project big.uvprojx, settings and files
target big (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: big +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/TaskLayer;../Application/DeviceLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Sensor;../Application/ProtocolLayer;../Application/ConfigLayer;../Application/DriverLayer;../Application/AlgorithmLayer;../Application/HardwareLayer;../Application/ModuleLayer;D:/work_apps/Keil_mdk_5.41/packs/ARM/CMSIS-DSP/1.16.2/Include;D:/work_apps/Keil_mdk_5.41/packs/ARM/CMSIS-DSP/1.16.2/Include/dsp;../Application/RobotLayer;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group User/Driver
    ../Application/DriverLayer/: drv_flash.c drv_tick.c drv_uart.c drv_can.c driver.c drv_tim.c WL_debug_uart.c WL_debug_uart.h
  group User/Protocol
    ../Application/ProtocolLayer/: rc_protocol.c can_protocol.c rm_protocol.c imu_protocol.h
  group User/Hardware
    ../Application/HardwareLayer/: RM_motor.c KT_motor.c DM_motor.c
  group User/Device/Imu
    ../Application/DeviceLayer/Imu/: bmi.c bmi_EKF.c BMI088driver.c BMI088Middleware.c kalman_filter.c
    ../Application/DeviceLayer/Sensor/: imu_sensor.c
  group User/Device
    ../Application/DeviceLayer/Sensor/: rc_sensor.c
    ../Application/DeviceLayer/: motor.c device.c cap.c Strategy.c Communicate.c slave.c slave.h select_strategy.c select_strategy.h
    ../Application/RobotLayer/: Chassis.c Chassis.h
  group User/Task
    ../Application/TaskLayer/: led_task.c control_task.c community_task.c monitor_task.c
  group User/Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h
  group User/Algorithm
    ../Application/AlgorithmLayer/: ave_filter.c rp_math.c PID.c crc.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2

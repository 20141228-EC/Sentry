# Keil uVision project big.uvprojx, settings and files
target big (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: big +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/TaskLayer;../Application/DeviceLayer;../Application/ProtocolLayer;../Application/ConfigLayer;../Application/DriverLayer;../Application/AlgorithmLayer;../Application/HardwareLayer;../Application/ModuleLayer;D:/work_apps/Keil_mdk_5.41/packs/ARM/CMSIS-DSP/1.16.2/Include;D:/work_apps/Keil_mdk_5.41/packs/ARM/CMSIS-DSP/1.16.2/Include/dsp;../Application/RobotLayer;../Application/DeviceLayer/Imu
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group User/Driver
    ../Application/DriverLayer/: drv_flash.c drv_tick.c drv_uart.c drv_can.c driver.c drv_tim.c WL_debug_uart.c
  group User/Protocol
    ../Application/ProtocolLayer/: can_protocol.c rm_protocol.c judge_protocol.c
  group User/Hardware
    ../Application/HardwareLayer/: RM_motor.c KT_motor.h KT_motor.c
  group User/Device/Imu
    ../Application/DeviceLayer/Imu/: bmi.c bmi_EKF.c BMI088driver.c BMI088Middleware.c kalman_filter.c imu_sensor.c imu_sensor.h
  group User/Device
    ../Application/DeviceLayer/: motor.c device.c cap.c judge.c master.c
  group User/Module
    ../Application/RobotLayer/: Chassis.c
  group User/Task
    ../Application/TaskLayer/: control_task.c led_task.c monitor_task.c community_task.c
  group User/Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h
  group User/Algorithm
    ../Application/AlgorithmLayer/: ave_filter.c rp_math.c PID.c crc.c ave_filter.h crc.h PID.h rp_math.h struct_typedef.h power_limit.c power_limit.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2

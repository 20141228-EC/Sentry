# Keil uVision project rp_template_hal_v1.uvprojx, settings and files
target rp_template_hal_v1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rp_template_hal_v1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,STM32F407xx,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_M
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/Driver;../Application/Algo;../Application/BMI;../Application/Remote;../Application/Motor;../Application/Vision;../Application/Chassic;../Application/Communicate;../Application/Config;../Application/Gimbal;../Application/Shoot;../Application/Judge;../Application/Cap;../Application/Oled
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/Driver
    ../Application/Driver/: driver.c drv_adda.c drv_can.c drv_haltick.c drv_io.c drv_tim.c drv_uart.c
  group Application/BMI
    ../Application/BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c soft_iic.c bmi270.c bmi270_context.c
  group Application/Algo
    ../Application/Algo/: rp_math.c dji_pid.c circular_buffer.c
  group Application/Chassic
    ../Application/Chassic/: rp_chassis.c chassic_Task.c
  group Application/Gimbal
    ../Application/Gimbal/: rp_gimbal.c gimbal_Task.c master_Task.c
  group Application/Communicate
    ../Application/Communicate/: can_protocol.c
  group Application/Remote
    ../Application/Remote/: remote.c
  group Application/Vision
    ../Application/Vision/: vision.c crc.c navigation.c
  group Application/Motor
    ../Application/Motor/: 9015_motor.c 3508_motor.c 2006_motor.c 6020_motor.c
  group README
    ../: note.txt
  group Application/Task
    ../Application/Task/: Check_task.c
  group Config
    ../Application/Config/: Car.c
  group Application/Shoot
    ../Application/Shoot/: rp_shoot.c shoot_Task.c
  group Application/Judge
    ../Application/Judge/: judge.c
  group Application/Cap
    ../Application/Cap/: cap_protocol.c cap.c
  group Application/Oled
    ../Application/Oled/: oled.c
software components: CMSIS:CORE 5.6.0
